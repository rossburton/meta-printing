inherit pypi setuptools3
require python-pycups.inc
