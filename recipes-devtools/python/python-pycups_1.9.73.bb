inherit pypi setuptools
require python-pycups.inc
