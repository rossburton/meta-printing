include cups-filters.inc

#SRC_URI = "https://github.com/Distrotech/${PN}/archive/release-1-5-0.tar.gz"
SRC_URI[md5sum] = "1a25ee2d3a58f229e78d250c1ac27fd9"
SRC_URI[sha256sum] = "8b3051911679d71ace27bd3f55b233253aaa29ce143d00978c0125eed0794919"
