include cups-filters.inc

#SRC_URI = "https://github.com/Distrotech/${PN}/archive/release-1-5-0.tar.gz"
SRC_URI[md5sum] = "3d8b28661daa8ffd5ae7ec0a7c3f6dd5"
SRC_URI[sha256sum] = "6ba1b29afdec79486597b818302e20abeb94b067a0ef151d2e1c8168e935dfd6"
