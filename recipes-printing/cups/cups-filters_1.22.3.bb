include cups-filters.inc

SRC_URI[md5sum] = "4a799ad0a5c868c62b247a7346a622f4"
SRC_URI[sha256sum] = "d3c675fe4416d3fdf47278d052a15e64b218305a76d7e8a1d20533a4eda8d8f7"

