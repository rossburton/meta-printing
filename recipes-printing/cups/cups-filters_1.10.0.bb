include cups-filters.inc

#SRC_URI = "https://github.com/Distrotech/${PN}/archive/release-1-5-0.tar.gz"
SRC_URI[md5sum] = "58370ca8e628e9a5f15009a1021f42cc"
SRC_URI[sha256sum] = "8de1473385ed0556f3aa488ee60a19c5f0c24b5a86e96c9b022c68275cb30900"
