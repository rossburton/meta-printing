include cups-filters.inc

SRC_URI[md5sum] = "1b8d893acef11bfe50d8dc7aea440c4f"
SRC_URI[sha256sum] = "715cd6b10114ba71bb1f444398bddf8e39dd7ac148b26a4c061965514321d7b9"

